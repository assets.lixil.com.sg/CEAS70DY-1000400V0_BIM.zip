Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2024-08-20T10:23:46
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.90.15 - Exporter 21.1.90.15 - Alternate UI 21.1.90.15
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Aug 20 10:23:46 2024 * Host: DCreative * Database: C:\Users\chatp\AppData\Local\Temp\2e1f8369-eda7-4ad6-8e4d-a65ad3f24704\80f14b77-aedd-4987-9016-956709cffa5b\ifc * Database version: 5507 * Database creation date: Tue Aug 20 10:23:42 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Aug 20 10:23:42 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Aug 20 10:23:42 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcDistributionPort (2)
Description: Flow
Name | FlowDirection
Port_348273 | SOURCE
Port_348273 | SINK

# IfcFlowTerminal: CEAS70DY-1000400V0_REVIT:E-lite Shower Toilet (w/battery for VN), CEAS70DY-1000400V0_REVIT:E-lite Shower Toilet (w/battery for VN):348273
In: Level 1
Type - Material: White
Type - Pset_ManufacturerTypeInformation - Manufacturer: American Standard
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Type - Pset_QuantityTakeOff - Reference: E-lite Shower Toilet (w/battery for VN)
Pset_DistributionFlowElementCommon - Reference: E-lite Shower Toilet (w/battery for VN); sets with these values: 2
